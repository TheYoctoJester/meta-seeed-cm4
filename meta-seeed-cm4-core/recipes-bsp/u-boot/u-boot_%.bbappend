BOOTENV_SIZE_seeed-reterminal ?= "0x1f000"
BOOTENV_SIZE_seeed-reterminal-mender ?= "0x1f000"